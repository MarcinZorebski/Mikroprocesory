# Keil uVision project mprc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mprc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: main.c frdm_bsp.h i2c.c i2c.h lcd1602.c lcd1602.h buttons.c buttons.h pit.c pit.h rtc.c rtc.h chess.c keypad.c keypad.h tpm.c tpm.h ws2812.c ws2812.h clock.c clock.h engine.c engine.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
